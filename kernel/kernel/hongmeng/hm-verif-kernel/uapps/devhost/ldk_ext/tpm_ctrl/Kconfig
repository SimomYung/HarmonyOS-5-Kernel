## kernel/kernel/linux-5.10-lts/drivers/devkit/lcdkit/Kconfig
```kconfig
#
# lcdkit driver configuration
#
source "drivers/devkit/lcdkit/lcdkit3.0/Kconfig"
```
